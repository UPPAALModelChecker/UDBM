## scripts/config.in
```kconfig
source      :@abs_top_srcdir@
build       :@abs_top_builddir@
cxxcompiler :@CXX@
ccompiler   :@CC@
cflags      :@CFLAGS@
```
